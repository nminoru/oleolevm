## linux-3.3.2-sparse/arch/x86/oleole/Kconfig
```kconfig
menu "OleOle"

config OLEOLE
	bool "Support for Ole-Ole-Virtual Memory"

endmenu
```
